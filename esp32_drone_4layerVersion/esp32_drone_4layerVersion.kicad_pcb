# Repository kstken0210/ESP_Drone

File README.md:

# ESP32-S3 Drone

以 **ESP32-S3** 為核心的四軸無人機專案，包含 4 層飛控板、手把式遙控器電路板，以及以 PlatformIO 建置的韌體。

## 專案狀態

| 項目 | 狀態 |
| --- | --- |
| 飛控板（4 層 PCB） | ✅ 設計完成，Gerber 已輸出 |
| 遙控器 PCB | ✅ 設計完成，Gerber 已輸出 |
| 韌體 | 🚧 僅完成硬體 bring-up 測試 |
| 飛行控制 | ⛔ 尚未實作 |

> `src/main.cpp` 目前只會透過序列埠輸出晶片資訊、讀取 GPIO 32，並每秒印出一個 `.`。
> PID、姿態解算、馬達混控、無線遙控與 failsafe 都還未加入，請不要把目前的韌體當成可飛行的飛控。

## 硬體

| 項目 | 內容 |
| --- | --- |
| MCU | ESP32-S3（DevKitC-1 腳位） |
| 感測器 | MPU-6050（六軸 IMU）、BMP3XX 系列氣壓計 |
| Flash | 16 MB |
| 無線 | Wi-Fi 2.4 GHz、Bluetooth 5 (LE) |
| 框架 | Arduino / PlatformIO |
| 硬體設計 | KiCad：飛控板 + 手把式遙控器 |

感測器型號來自 `platformio.ini` 的 `lib_deps`；實際焊接型號、I2C 位址與腳位請以 PCB 和 BOM 為準。

### 電路板與 Gerber

- `esp32_drone_4layerVersion/` — 飛控主板，4 層板。內含 KiCad 原理圖、PCB、netlist、CAM 子圖與 `ESP_drone_gerber/`。
- `esp32_drone_controller/` — 手把式遙控器板。內含 KiCad 原理圖、PCB、netlist、自訂 `touch_pad.pretty` 封裝與 `controller_gerber/`。
- `Image/` — 實板照片。

用 KiCad 開啟各目錄下的 `.kicad_pro` 即可編輯；`*_gerber/` 內是可直接送廠的 Gerber/鑽孔檔。

## 目錄結構

```text
ESP_drone/
├── src/main.cpp                  # 目前唯一的應用程式進入點
├── include/                      # 專案標頭（目前為 PlatformIO 預設說明）
├── lib/                          # 私有函式庫（目前為 PlatformIO 預設說明）
├── test/                         # 測試（目前為 PlatformIO 預設說明）
├── esp32_drone_4layerVersion/    # 飛控板 KiCad + Gerber
├── esp32_drone_controller/       # 遙控器 KiCad + Gerber
├── Image/                        # 實板照片
├── platformio.ini                # PlatformIO 環境設定
├── sdkconfig.defaults            # ESP-IDF 預設設定
└── .gitignore
```

## 開發環境

需要 **VS Code + PlatformIO IDE**，或獨立的 **PlatformIO Core**：

```bash
pip install platformio
```

### 建置與燒錄

```bash
# 建置
pio run

# 燒錄（自動選擇序列埠）
pio run --target upload

# 看序列埠輸出
pio device monitor --baud 115200
```

如果電腦接有多個序列裝置，請明確指定埠：

```bash
pio run --target upload --upload-port COM5
pio device monitor --port COM5 --baud 115200
```

### 設定重點

`platformio.ini` 目前的使用設定：

| 設定 | 值 | 說明 |
| --- | --- | --- |
| `platform` | `espressif32@6.5.0` | 固定版本，避免平台更新造成差異 |
| `board` | `esp32-s3-devkitc-1` | ESP32-S3 DevKitC-1 |
| `framework` | `arduino` | Arduino-ESP32 |
| `board_upload.flash_size` | `16MB` | 對應 16 MB Flash 的板子 |
| `board_build.partitions` | `default_16MB.csv` | 16 MB 分區表 |
| `board_build.flash_mode` | `dio` | 使用 DIO，而非 QIO/OPI |
| PSRAM | 關閉 | `board_build.psram = disabled`、`BOARD_HAS_PSRAM=0` |
| USB CDC | 關閉 | `ARDUINO_USB_MODE=0`、`ARDUINO_USB_CDC_ON_BOOT=0` |
| 除錯等級 | `CORE_DEBUG_LEVEL=5` | 開發期詳細 log；量產可調低 |

`sdkconfig.defaults` 另外固定了：

```text
CONFIG_SPIRAM=n
CONFIG_ESP32S3_DEFAULT_CPU_FREQ_240=y
CONFIG_ESPTOOLPY_FLASHMODE_DIO=y
CONFIG_ESPTOOLPY_FLASHFREQ_80M=y
```

> 如果你的板子不是 16 MB Flash，請先改 `board_upload.flash_size` 與分區表，否則燒錄後可能無法正常啟動。

## 預期的 bring-up 輸出

燒錄後開啟 115200 序列埠，應該會看到類似：

```text
===============================
 ESP32-S3 Basic Test
===============================
Free Heap: 123456 bytes
Chip Revision: 0
CPU Frequency: 240 MHz
GPIO 32 state: 1
System is stable!
.
.
```

這段程式只驗證三件事：序列埠、晶片基本資訊、GPIO 32 輸入。

## 開發路線圖

- [x] 4 層飛控板設計與 Gerber 輸出
- [x] 手把式遙控器板設計與 Gerber 輸出
- [x] PlatformIO 專案與 ESP32-S3 bring-up
- [x] MPU-6050 初始化、校正與姿態解算
- [ ] BMP3XX 氣壓／高度讀取
- [ ] PID 控制器與馬達混控
- [x] 遙控器無線協定（Wi-Fi / BLE / 2.4 GHz）
- [ ] Failsafe、低電壓保護與解鎖邏輯
- [ ] 室內懸停測試與戶外飛行測試
- [ ] 遙測與地面站

## 疑難排解

| 問題 | 建議 |
| --- | --- |
| 找不到序列埠 | 確認 USB 線可傳資料（不是純充電線）、安裝 CP210x/CH340 驅動，或換一個 USB 埠 |
| 燒錄失敗 | 按住 BOOT 再按 RESET 進入下載模式；必要時把 `upload_speed` 降到 `460800` |
| 開序列埠沒有輸出 | 此專案關閉了 USB CDC，請接 UART 腳位（TX/RX）並以 115200 開啟 |
| 一直重啟 | 檢查供電是否足夠、Flash 大小與分區表是否匹配 |
| PSRAM 相關錯誤 | 本專案刻意關閉 PSRAM；除非板子確定有 PSRAM，否則不要開啟 |

## 版本控制說明

`.gitignore` 已排除下列本機產生內容：

- `.pio/` — PlatformIO 建置快取與下載的套件（可達數十 MB）
- `.history/` — VS Code Local History，會保存大量檔案快照
- `.vscode/c_cpp_properties.json`、`.vscode/launch.json`、`.vscode/ipch/` — 由 PlatformIO 產生，內含本機絕對路徑
- `sdkconfig`、`build/`、`*.bin`、`*.elf`、`*.map` — 建置產物
- `*.kicad_prl`、`fp-info-cache`、`_autosave-*`、`*-backups/` — KiCad 本機設定與自動備份

KiCad 的 `.kicad_pro`、`.kicad_pcb`、`.kicad_sch`、`.net`、Gerber 與 `.zip` **不會**被忽略，會正常納入版控。

## 授權

本專案目前未附 `LICENSE`。

## KiCad design esp32_drone_4layerVersion/esp32_drone_4layerVersion.kicad_pcb

Parts:
C1, C14: 1uF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C4, C5, C17, C21, C23, C24, C27: 22uF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C15, C16, C18, C19, C25, C26: 10uF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C20, C22: 0.1uF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
D1: D_Schottky; D_SOD-123
D2, D8, D9: LED; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
D10: SMAJ5.0A; D_SOD-123F
F1: Fuse; Fuse_1206_3216Metric
J2: Conn_01x02_Pin; PinHeader_1x02_P2.00mm_Vertical
J3: USB_C_Receptacle_USB2.0_16P; USB_C_Receptacle_GCT_USB4105-xx-A_16P_TopMnt_Horizontal
L2: 4.7uH; L_Sunlord_SWPA4020S
R1, R2: 10k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R3, R4: 4.7k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R8, R9: 5.1k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R15, R16: 220ohm; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R27: 15k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R28: 110k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R37: 2k->2.85k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R38: 330R; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R41: 220R; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R42: 270R; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
SW4, SW5: SW_SPST; SW_SPST_TS-1088-xR025
U1: ESP32-S3-WROOM-1U-N16R8; XCVR_ESP32-S3-WROOM-1U-N16R8; PARTREV v1.1
U2: USBLC6-2SC6; SOT-23-6
U3: MT3608; SOT-23-6
U5: LTC4054; SOT23-5L
U6: AMS1117-3.3; SOT-223-3_TabPin2
U7: AMS1117-3.3/-1.2; SOT-89-3
U9: AMS1117; SOT-89-3
U10: AMS1117-3.3; SOT-89-3
U11: AO3404; SOT23-3

Connections:
/5V_ined: C14.2, R38.2, U5.4 (VCC), U11.2
/CC1_wire: J3.A5 (CC1), R8.1
/CC2_wire: J3.B5 (CC2), R9.1
/VBUS_1: C19.2, C20.2, D10.1 (A1), F1.1, J3.A4 (VBUS), J3.A9 (VBUS), J3.B4 (VBUS), J3.B9 (VBUS), U2.5 (VBUS)
AGND: C23.2, R42.2; also elsewhere on the board
BAT: C4.1, C15.2, J2.1, L2.1, U3.4 (EN), U3.5 (IN), U5.3 (BAT); also elsewhere on the board
Boot: R2.1, U1.27 (IO0)
CAM_HREF: U1.32 (IO39); also elsewhere on the board
CAM_PCLK: U1.20 (IO12); also elsewhere on the board
CAM_SCL: U1.35 (IO42); also elsewhere on the board
CAM_SDA: U1.34 (IO41); also elsewhere on the board
CAM_VS: U1.33 (IO40); also elsewhere on the board
CAM_XCLK: U1.17 (IO9); also elsewhere on the board
D2: U1.22 (IO14); also elsewhere on the board
D3: U1.24 (IO47); also elsewhere on the board
D4: U1.25 (IO48); also elsewhere on the board
D5: U1.23 (IO21); also elsewhere on the board
D6: U1.21 (IO13); also elsewhere on the board
D7: U1.19 (IO11); also elsewhere on the board
D8: U1.18 (IO10); also elsewhere on the board
D9: U1.15 (IO3); also elsewhere on the board
D+: J3.A6 (D+), J3.B6 (D+), U1.14 (IO20), U2.1 (I/O1), U2.6 (I/O1)
D-: J3.A7 (D-), J3.B7 (D-), U1.13 (IO19), U2.3 (I/O2), U2.4 (I/O2)
EN: C1.2, R1.2, SW4.2 (B), U1.3 (EN)
GND: C1.1, C4.2, C5.2, C14.1, C15.1, C16.2, C17.2, C18.2, C19.1, C20.1, C21.1, C22.1, C24.2, C25.2, C26.2, C27.2, D8.1 (K), D9.1 (K), D10.2 (A2), J2.2, J3.A1 (GND), J3.A12 (GND), J3.B1 (GND), J3.B12 (GND), J3.SH (SHIELD), R8.2, R9.2, R27.2, R37.1, SW4.1 (A), SW5.1 (A), U1.1 (GND), U1.40 (GND), U1.41_1 (GND), U1.41_2 (GND), U1.41_3 (GND), U1.41_4 (GND), U1.41_5 (GND), U1.41_6 (GND), U1.41_7 (GND), U1.41_8 (GND), U1.41_9 (GND), U2.2 (GND), U3.2 (GND), U5.2 (GND), U6.1 (GND), U7.1 (GND), U10.1 (GND), U11.1; also elsewhere on the board
unnamed: D1.2 (A), L2.2, U3.1 (SW)
unnamed: D2.2 (A), R38.1
unnamed: D2.1 (K), U5.1 (CHRG)
unnamed: D8.2 (A), R15.2
unnamed: D9.2 (A), R16.2
unnamed: R2.2, SW5.2 (B)
unnamed: R27.1, R28.2, U3.3 (FB)
unnamed: R37.2, U5.5 (PROG)
unnamed: R41.2, R42.1, U9.1 (ADJ)
PWM1: U1.6 (IO6); also elsewhere on the board
PWM2: U1.7 (IO7); also elsewhere on the board
PWM3: U1.8 (IO15); also elsewhere on the board
PWM4: U1.9 (IO16); also elsewhere on the board
Peri_3V: C27.1, U10.2 (VO); also elsewhere on the board
SCL: R4.1, U1.39 (IO1); also elsewhere on the board
SDA: R3.1, U1.38 (IO2); also elsewhere on the board
SYS_1.2V: C24.1, U7.2 (VO); also elsewhere on the board
SYS_2.8V: C23.1, R41.1, U9.2 (VO); also elsewhere on the board
SYS_3V: C17.1, C18.1, C21.2, C22.2, R1.1, R3.2, R4.2, R16.1, U1.2 (3V3), U6.2 (VO), U7.3 (VI); also elsewhere on the board
SYS_5V: C5.1, C16.1, C25.1, C26.1, D1.1 (K), R15.1, R28.1, U6.3 (VI), U9.3 (VI), U10.3 (VI)
Typec_5V: F1.2, U11.3

Notes on the sheet:
No need 1.5k上拉 with 3.3v 22ohm
SOT封裝
Needed for: MPU6050 0V2640 ELRS TX RX PWM *4 氣壓模組
35,36,37 不能用 0,45,46 慎用 3,9,10,11,12,13,14,21,47,48 D8 4,5,6,7 CLK 1,2 iic2
BOOT
有電會充no need sw
Type-c
parallel 接綫 sensor and esp get from 1 ldo 粗like may need 10mm
默認上拉
B240A
footprint 可能jst check tb
升壓電路
Can NMOS but just two gnd prob Gate side->VCC source side->sys gnd drain side->bat/final gnd
充電電路
still match
B340A
SMAJ
just choose SOT89 is fine 裏面的pin 順序no need care as 你買的時候照著ams1117 SOT89 即可
狀態檢測
GND->low curr->高阻抗

Parts:
C6: 10nF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C7, C8, C11: 0.1uF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C9: 2.2nF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C10, C13: 10uF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C28, C29, C30, C31: 4.7uF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
D3, D6, D7, D11: D_Schottky; D_SOD-123
H1, H2, H3, H4: MountingHole; MountingHole_3.2mm_M3
M1, M2, M3, M4: Motor_DC; Molex_PicoBlade_53047-0210_1x02_P1.25mm_Vertical
R7, R11, R13, R17: 100Ω; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R10, R12, R14, R18: 10k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
TP2_GND1, TP3_SCL1, TP4_SDA1, TP5_DRDY1: TestPoint; TestPoint_Pad_2.0x2.0mm
TP_VCC1: TestPoint; TestPoint_Pad_2.0x2.0mm
U4: MPU-6050; InvenSense_QFN-24_4x4mm_P0.5mm
U8: BMP388; XDCR_BMP388; PARTREV 1.7
U12, U13, U14, U15: AO3400; SOT23

Connections:
BAT: C28.2, C29.2, C30.2, C31.2, D3.1 (K), D6.1 (K), D7.1 (K), D11.1 (K), M1.1 (+), M2.1 (+), M3.1 (+), M4.1 (+); also elsewhere on the board
GND: C6.1, C7.1, C8.2, C9.2, C10.1, C11.1, C13.2, R10.2, R12.2, R14.2, R18.2, TP2_GND1.1 (1_1), U4.1 (CLKIN), U4.9 (AD0), U4.11 (FSYNC), U4.18 (GND), U8.3 (VSS), U8.5 (SDO), U8.8 (VSS), U8.9 (VSS), U12.2, U13.2, U14.2, U15.2; also elsewhere on the board
unnamed: C29.1, D3.2 (A), M1.2 (-), U15.3
unnamed: C28.1, D6.2 (A), M2.2 (-), U14.3
unnamed: C30.1, D7.2 (A), M3.2 (-), U12.3
unnamed: C31.1, D11.2 (A), M4.2 (-), U13.3
unnamed: R7.1, R10.1, U15.1
unnamed: R11.1, R12.1, U14.1
unnamed: R13.1, R14.1, U12.1
unnamed: R17.1, R18.1, U13.1
unnamed: C9.1, U4.20 (CPOUT)
unnamed: C8.1, U4.10 (REGOUT)
PWM1: R7.2; also elsewhere on the board
PWM2: R11.2; also elsewhere on the board
PWM3: R13.2; also elsewhere on the board
PWM4: R17.2; also elsewhere on the board
Peri_3V: C6.2, C7.2, C10.2, C11.2, C13.1, TP_VCC1.1 (1_1), U4.8 (VLOGIC), U4.13 (VDD), U8.1 (VDDIO), U8.6 (CSB), U8.10 (VDD); also elsewhere on the board
SCL: TP3_SCL1.1 (1_1), U4.23 (SCL), U8.2 (SCK); also elsewhere on the board
SDA: TP4_SDA1.1 (1_1), U4.24 (SDA), U8.4 (SDI); also elsewhere on the board

Notes on the sheet:
Mode select
0x76
推力選型
表面焊盤的「半表面貼裝 (Castellated/SMD Stack)」焊接手法 No 通孔 just 表面padding
MPU6050
GY-271是模塊but still check check just 飛綫？
外部脈衝 同步output
so many from esp ok? look back to the notes at esp3.3v
716 空心杯
自己留位置
Diode選型
直接貼
SI2302
Or use diode for back EMF
check INT code

Parts:
C2: 1uF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C12: 2.2uF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C33: 10uF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C35: 4.7uF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
CAM1: OV2640
R20: 100k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R21, R22: 2k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R23: 10k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R24, R25, R26: 22R; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R29: 0R; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder

Connections:
AGND: C35.2, CAM1.2 (AGND), R29.1; also elsewhere on the board
CAM_HREF: R26.2; also elsewhere on the board
CAM_PCLK: R24.2; also elsewhere on the board
CAM_SCL: CAM1.5 (SIO_C), R22.1; also elsewhere on the board
CAM_SDA: CAM1.3 (SIO_D), R21.2; also elsewhere on the board
CAM_VS: CAM1.7 (VSYNC); also elsewhere on the board
CAM_XCLK: R25.1; also elsewhere on the board
D2: CAM1.19 (DATA2); also elsewhere on the board
D3: CAM1.21 (DATA3); also elsewhere on the board
D4: CAM1.22 (DATA4); also elsewhere on the board
D5: CAM1.20 (DATA5); also elsewhere on the board
D6: CAM1.18 (DATA6); also elsewhere on the board
D7: CAM1.16 (DATA7); also elsewhere on the board
D8: CAM1.14 (DATA8); also elsewhere on the board
D9: CAM1.12 (DATA9); also elsewhere on the board
GND: C2.1, C12.2, C33.2, CAM1.15 (DGND), CAM1.MT1 (DGND), CAM1.MT2 (DGND), R20.1, R29.2; also elsewhere on the board
unnamed: CAM1.9 (HREF), R26.1
unnamed: CAM1.17 (PCLK), R24.1
unnamed: CAM1.8 (PWDN), R20.2
unnamed: CAM1.13 (XCLK), R25.2
Peri_3V: C33.1, CAM1.11 (DOVDD), R23.1; also elsewhere on the board
RESET_CAM: C2.2, CAM1.6 (RESET), R23.2
SYS_1.2V: C12.1, CAM1.10 (DVDD); also elsewhere on the board
SYS_2.8V: C35.1, CAM1.4 (AVDD); also elsewhere on the board
SYS_3V: R21.1, R22.2; also elsewhere on the board

Notes on the sheet:
Near pin to absore 反射波 two wire near as similar hz
0R->100R/22R
Near with DATA not CLK as hz dif
留意PCB走綫 like CLK need care
100nF 22uF
拉力更强
留意買的時候 18/24 pin OV2640最方便 FPC/FFC Connector
No need extra header buy 24 pin 的FPC/FEC header
Normally DGND X agnd/gnd
1.22R/100R/2k 2.LDO 3.PLCK/XCLK/IIC/DATA/HREF/VS不能放太近 4.RS 5.power with 100nF 22uF
Not Must
IS like have header connect CAM and ESP

Board: 4 copper layers, 64.0 x 64.0 mm, 106 parts (25 on the bottom side), 61 nets.

## KiCad design esp32_drone_controller/esp32_drone_controller.kicad_pcb

Parts:
C1, C14, C18, C23: 1uF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C4, C5, C17, C21: 22uF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C8, C15, C16, C19: 10uF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C20, C22: 0.1uF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
D1: D_Schottky; D_SOD-123
D2, D8, D9: LED; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
D10: SMAJ5.0A; D_SOD-123F
F1: Fuse; Fuse_1206_3216Metric
J1: USB_C_Receptacle_USB2.0_14P; USB_C_Receptacle_GCT_USB4105-xx-A_16P_TopMnt_Horizontal
J2: Conn_01x02_Pin; Molex_PicoBlade_53047-0210_1x02_P1.25mm_Vertical
L2: 4.7uH; L_Sunlord_SWPA6045S
R1, R2: 10k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R3, R4: 4.7k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R5: 100k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R8, R9: 5.1k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R10: 200k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R15, R16: 220ohm; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R27: 15k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R28: 110k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R37: 2.8k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R38: 330R; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
SW1, SW2: SW_DPST_x2; SW_SPST_TS-1088-xR025
U1: ESP32-S3-WROOM-1U-N16R8; XCVR_ESP32-S3-WROOM-1U-N16R8; PARTREV v1.1
U2: USBLC6-2SC6; SOT-23-6
U3: MT3608; SOT-23-6
U4: AP2112K-3.3; SOT-23-5
U5: LTC4054; SOT23-5L
U6: AMS1117-3.3; SOT-223-3_TabPin2
U11: AO3404; SOT23-3

Connections:
/5V_ined: C14.2, R38.2, U5.4 (VCC), U11.2
/CC1_wire: J1.A5 (CC1), R8.1
/CC2_wire: J1.B5 (CC2), R9.1
/VBUS_1: C19.2, C20.2, D10.1 (A1), F1.1, J1.A4 (VBUS), J1.A9 (VBUS), J1.B4 (VBUS), J1.B9 (VBUS), U2.5 (VBUS)
ADC1: C8.1, R5.2, R10.1, U1.8 (IO15)
ADC2: U1.25 (IO48); also elsewhere on the board
ADC3: U1.24 (IO47); also elsewhere on the board
ADC4: U1.19 (IO11); also elsewhere on the board
ADC5: U1.18 (IO10); also elsewhere on the board
BAT: C4.1, C15.2, J2.1, L2.1, R5.1, U3.4 (EN), U3.5 (IN), U5.3 (BAT)
Boot: R2.1, U1.27 (IO0)
D+: J1.A6 (D+), J1.B6 (D+), U1.14 (IO20), U2.1 (I/O1), U2.6 (I/O1)
D-: J1.A7 (D-), J1.B7 (D-), U1.13 (IO19), U2.3 (I/O2), U2.4 (I/O2)
DO1: U1.23 (IO21); also elsewhere on the board
DO2: U1.17 (IO9); also elsewhere on the board
EN: C1.2, R1.2, SW1.1 (A), U1.3 (EN)
GND: C1.1, C4.2, C5.2, C8.2, C14.1, C15.1, C16.2, C17.2, C18.2, C19.1, C20.1, C21.1, C22.1, C23.2, D8.1 (K), D9.1 (K), D10.2 (A2), J1.A1 (GND), J1.A12 (GND), J1.B1 (GND), J1.B12 (GND), J1.SH (SHIELD), J2.2, R8.2, R9.2, R10.2, R27.2, R37.1, SW1.2 (B), SW2.2 (B), U1.1 (GND), U1.40 (GND), U1.41_1 (GND), U1.41_2 (GND), U1.41_3 (GND), U1.41_4 (GND), U1.41_5 (GND), U1.41_6 (GND), U1.41_7 (GND), U1.41_8 (GND), U1.41_9 (GND), U2.2 (GND), U3.2 (GND), U4.2 (GND), U5.2 (GND), U6.1 (GND), U11.1; also elsewhere on the board
unnamed: D1.2 (A), L2.2, U3.1 (SW)
unnamed: D2.2 (A), R38.1
unnamed: D2.1 (K), U5.1 (CHRG)
unnamed: D8.2 (A), R15.2
unnamed: D9.2 (A), R16.2
unnamed: R2.2, SW2.1 (A)
unnamed: R27.1, R28.2, U3.3 (FB)
unnamed: R37.2, U5.5 (PROG)
SCL: R4.1, U1.21 (IO13); also elsewhere on the board
SDA: R3.1, U1.22 (IO14); also elsewhere on the board
SW1: U1.31 (IO38); also elsewhere on the board
SW2: U1.32 (IO39); also elsewhere on the board
SW3: U1.33 (IO40); also elsewhere on the board
SW4: U1.34 (IO41); also elsewhere on the board
SW5: U1.35 (IO42); also elsewhere on the board
SW6: U1.38 (IO2); also elsewhere on the board
SYS_3V: C17.1, C21.2, C22.2, R1.1, R3.2, R4.2, R16.1, U1.2 (3V3), U6.2 (VO); also elsewhere on the board
SYS_5V: C5.1, C16.1, C18.1, D1.1 (K), R15.1, R28.1, U4.1 (VIN), U4.3 (EN), U6.3 (VI); also elsewhere on the board
TOUCH_1: U1.26 (IO45); also elsewhere on the board
TOUCH_2: U1.15 (IO3); also elsewhere on the board
TOUCH_3.3V: C23.1, U4.5 (VOUT); also elsewhere on the board
Typec_5V: F1.2, U11.3

Notes on the sheet:
TOUCH1,2 DO1,2 ADC2,3,4,5 放下面 SW1-6 放右邊 SCL/SDA 可以放下就下，不行就右邊下
No need 1.5k上拉 with 3.3v 22ohm
SOT封裝
Learnt
35,36,37 不能用 0,45,46 慎用 3,9,10,11,12,13,14,21,47,48 D8 4,5,6,7 CLK 1,2 iic2
BOOT
有電會充no need sw
Type-c
默認上拉
0.5mm 星型接地 for esp and oled,esp and joystick
footprint 可能jst check tb
升壓電路
Can NMOS but just two gnd prob Gate side->VCC source side->sys gnd drain side->bat/final gnd
充電電路
CMOS
狀態檢測
MAX 6V
