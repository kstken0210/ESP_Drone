# Repository kstken0210/ESP_Drone (continued)

## KiCad design esp32_drone_controller/esp32_drone_controller.kicad_pcb (continued)

Parts:
C2, C7: 8.2nF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C3, C6, C11, C24, C25, C26, C27, C28: 0.1uF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
J3, J4: Conn_01x01_Pin; touch_pad_10mm_circle
J5, J7: Conn_01x05; PinSocket_1x05_P2.54mm_Horizontal
J6: OLED; PinSocket_1x04_P2.54mm_Vertical
R6, R7: 4.7k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R11, R13, R17, R19: 110k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R12, R14, R18, R20: 220k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R21, R22, R23, R24, R25, R26: 1k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
SW3, SW4, SW5, SW6, SW7, SW8: SW_Push; SW_PUSH_6mm
U7, U8: AT42QT1011-TSHR; SOT-23-6

Connections:
ADC2: C25.1, R11.2, R12.1; also elsewhere on the board
ADC3: C26.1, R13.2, R14.1; also elsewhere on the board
ADC4: C27.1, R17.2, R18.1; also elsewhere on the board
ADC5: C28.1, R19.2, R20.1; also elsewhere on the board
ADC_TEMP2: J5.3, R11.1
ADC_TEMP3: J5.2, R13.1
ADC_TEMP4: J7.3, R17.1
ADC_TEMP5: J7.2, R19.1
DO1: J5.1; also elsewhere on the board
DO2: J7.1; also elsewhere on the board
GND: C3.1, C6.1, C11.2, C24.2, C25.2, C26.2, C27.2, C28.2, J5.5, J6.1, J7.5, R12.2, R14.2, R18.2, R20.2, R21.2, R22.2, R23.2, R24.2, R25.2, R26.2, U7.2 (VSS), U7.6 (SYNC), U8.2 (VSS), U8.6 (SYNC); also elsewhere on the board
unnamed: J3.1 (Pin_1_1), R6.2
unnamed: J4.1 (Pin_1_1), R7.2
unnamed: R21.1, SW3.2
unnamed: R22.1, SW4.2
unnamed: R23.1, SW5.2
unnamed: R24.1, SW6.2
unnamed: R25.1, SW7.2
unnamed: R26.1, SW8.2
unnamed: C2.1, U7.4 (SNS)
unnamed: C2.2, R6.1, U7.3 (SNSK)
unnamed: C7.1, U8.4 (SNS)
unnamed: C7.2, R7.1, U8.3 (SNSK)
SCL: J6.3; also elsewhere on the board
SDA: J6.4; also elsewhere on the board
SW1: SW3.1; also elsewhere on the board
SW2: SW4.1; also elsewhere on the board
SW3: SW5.1; also elsewhere on the board
SW4: SW6.1; also elsewhere on the board
SW5: SW7.1; also elsewhere on the board
SW6: SW8.1; also elsewhere on the board
SYS_3V: J6.2; also elsewhere on the board
SYS_5V: J5.4, J7.4; also elsewhere on the board
TOUCH_1: C24.1, U8.1 (OUT); also elsewhere on the board
TOUCH_2: C11.1, U7.1 (OUT); also elsewhere on the board
TOUCH_3.3V: C3.2, C6.2, U7.5 (VDD), U8.5 (VDD); also elsewhere on the board

Notes on the sheet:
TOUCH1,2 DO1,2 ADC2,3,4,5 放下面 SW1-6 放右邊
上拉輸入(no need as 自帶)
0.3mm 0.15mm
Learnt
每一個ADC都要+分壓電阻and 100nF Cap
INPUT analog voltage?
Need one more LDO if <500mA use LDO

Board: 2 copper layers, 110.0 x 60.5 mm, 85 parts (12 on the bottom side), 55 nets.
